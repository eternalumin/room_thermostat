# Keil uVision project Thermostat.uvprojx, settings and files
target RoomThermostat (MCS-51)
  device: AT89C51 Atmel
  output: RoomThermostat +hex
  group Source Files
    ./:    
  group Header Files
    ./:   
